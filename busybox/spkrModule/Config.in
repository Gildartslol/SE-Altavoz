## busybox/spkrModule/Config.in
```kconfig
config BR2_PACKAGE_KERNEL_MODULE
	bool "spkrModule"
	depends on BR2_LINUX_KERNEL
	help
		Linux Kernel SPKR module.
```
